# Keil uVision project Balance_Car.uvprojx, settings and files
target Balance_Car (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Balance_Car +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;   ../Drivers/CMSIS/Include;   ..\SYSTEM\iic;   ..\SYSTEM\sys;   ..\HARDWARE\mpu6050;   ..\HARDWARE\dmp;   ..\HARDWARE\datascope_dp;   ..\HARDWARE\control;   ..\HARDWARE\motor;   ..\HARDWARE\encoder
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/iic/: iic.c
  group HARDWARE
    ../HARDWARE/mpu6050/: mpu6050.c
    ../HARDWARE/dmp/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/datascope_dp/: datascope_dp.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/control/: control.c
    ../HARDWARE/encoder/: encoder.c
software components: CMSIS:CORE 4.3.0
